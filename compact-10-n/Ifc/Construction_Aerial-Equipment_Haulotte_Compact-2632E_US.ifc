Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-06-13T13:29:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jun 13 13:29:22 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{1E56853A-5FB1-4E9C-A91F-2B18CAFD224D}\ifc * Database version: 5507 * Database creation date: Sat Jun 13 13:29:13 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jun 13 13:29:14 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jun 13 13:29:14 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 2632 E, Construction_Aerial-Equipment_Haulotte_Compact-2632E_US:Compact 2632 E:1394895
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Yellow, Metal - Haulotte - Black, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - White, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 75 l (20 gal); Machine Weight: 3520 kg (7762 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 2632 E; Nom du type: Compact 2632 E; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/compact-10-n; Titre OmniClass: Other Utility and Transportation Construction Products; URL: https://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 4x24V- 180 Ah; Driveable at Full Height up to: 8.1 m / 318,90 in; Drive Speed: 0.8-3 km/h / 0.50 - 1.86 mph; Gradeability: 32°; Ground Clearance: 70 mm / 2,76 in; Ground Clearance - Pothole Guards Deployed: 15 mm / 0,59 in; Height - Stowed: 2.175 m / 65,63 in; Length: 2.475 m / 97,44 in; Length Extension: 0.92 m / 36,22; Lift Capacity – Inside: 230 Kg / 500 lb; Lift Capacity - Outside: N/A; Max Ground Pressure of Wheel on Paved Ground: 20.2 Kg/cm2; Overall Width: 0.815 m / 32,09 in; Platform Height: 8.1 m / 318,90 in; Platform Length - Extended: 3.23 m / 127,17; Platform Length - Outside: 2.31 m / 90,94 in; Platform Width – Outside: 735 mm / 28,94 in; Tilt: 1.5° / 3°; Tires: 378x125x32 mm / 14.88x4.92x 12.72 in; Turning Radius - Inside: 0.2 m / 7.87 in; Turning Radius - Outside: 2.38 m / 93.70 in; Wheelbase: 1.86 m / 73,23 in; Working Height: 10.1 m / 397,64 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US:Compact 2632 E
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US: Compact 2632 E; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US: Compact 2632 E; H CTRL: 7.521 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US: Compact 2632 E; L: 1.04267 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-2632E_US: Compact 2632 E
Construction - Extension Desk Length: 1.17 m; Platform Height: 8.1 m; Reach Diagram: yes; Turning Radius: yes; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 54.101 m2; Volume: 19.3371 m3
Données d'identification - Variantes: COMPACT (principale)
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
